# Keil uVision project cubic_further.uvprojx, settings and files
target hello_world debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/io;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/log;../../../../../devices/MIMXRT1052/utilities;../../../../../devices/MIMXRT1052/xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_ram.scf
  link misc: --remove
  group startup
    ../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group Application
    ../../../user/: main.c rtconfig.h
    ../../../user/bsp/led/: bsp_led.c
    ../../../user/GUI_Demo/: MOTION_SmartPhoneMenu.c IconView.c
  group Libraries
    ../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_elcdif.c fsl_gpio.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpuart.c fsl_lpuart_edma.c fsl_pwm.c fsl_pxp.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_edma.c fsl_qtmr.c fsl_adc.c
    ../../devices/MIMXRT1052/: system_MIMXRT1052.c
  group utilities
    ../../devices/MIMXRT1052/utilities/io/: fsl_io.c
    ../../devices/MIMXRT1052/utilities/log/: fsl_log.c
    ../../devices/MIMXRT1052/utilities/str/: fsl_str.c
    ../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_shell.c fsl_sbrk.c
  group Drives
    ../../../user/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
    ../../../rtthread/3.0.3/drivers/: drv_cache.c drv_i2c.c drv_pin.c drv_sdram.c drv_spi_bus.c drv_uart.c drv_rtc.c
    ../../../user/bsp/lcd/: elcdif_rgb.c
  group GUI
    ../../middleware/emwin/emWin_Config/: emwin_support.c GUIConf.h emwin_support.h
    ../../middleware/emwin/: GUI_X_OS.c
    ../../middleware/emwin/emWin_library/Keil/: emWin_M4F.lib
  group xip
    ../../devices/MIMXRT1052/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group rtt/source
    ../../../rtthread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
    ../../../rtthread/3.0.3/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
    ../../../rtthread/3.0.3/include/libc/: libc_dirent.h libc_errno.h libc_fcntl.h libc_fdset.h libc_ioctl.h libc_signal.h libc_stat.h
  group rtt/ports
    ../../../rtthread/3.0.3/libcpu/arm/cortex-m7/: context_rvds.S cpuport.c
  group DeviceDrive
    ../../../rtthread/3.0.3/components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../rtthread/3.0.3/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../rtthread/3.0.3/components/drivers/misc/: pin.c
    ../../../rtthread/3.0.3/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../../rtthread/3.0.3/components/drivers/serial/: serial.c
    ../../../rtthread/3.0.3/components/drivers/rtc/: rtc.c
  group libc
    ../../../rtthread/3.0.3/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
  group fonts
    ../../../user/fonts/: Dingbats2114.c HelveticaNeueLT Pro 45 Lt76.c HelveticaNeueLT Pro 65 Md45.c HelveticaNeueLT Pro 65 Md75.c HelveticaNeueLT Pro 65 Md113.c HoloLens MDL2 Assets35.c HoloLens MDL2 Assets64.c Open Sans51.c PingFang_Regular41.c PingFang_Regular45.c PingFang_Regular49.c PingFang_Regular52.c PingFang_Regular52_2.c PingFang_Regular67.c PingFang_Regular67_2.c PingFang_Regular90.c PingFang_Regular135.c Pingfang34.c PingFang67.c Source Han Sans Regular67.c ydfont32.c ydfont44.c ydfont46.c ydfont47.c ydfont54.c ydfont62.c ydinsertfont40.c HoloLens MDL2 Assets48.c HoloLens MDL2 Assets133.c hanyi48.c hanyi60.c hanyi43.c
  group bsp_driver
    ../../../user/bsp/: bsp_adc_bat.c bsp_basetimer.c bsp_board_init.c bsp_cgk_module.c bsp_i2c_gpio.c bsp_i2cdev_init.c bsp_powerpwm.c bsp_sdram.c bsp_spiflash.c bsp_spiflash2.c bsp_ts_ft6336_sf.c bsp_uartwifi.c
  group fatfs
    ../../../user/fatfs/: diskio.c ff.c ff.h
    ../../../user/fatfs/option/: cc936.c
  group png
    ../../../user/png/: co2bar.c iconbrowse.c iconco2.c iconco2knowledge.c icondustknowledge.c iconelecradknowledge.c iconknow.c iconperformanceparameter.c iconuv.c iconuvknowledge.c pmbar.c returnbkleft.c returnbkright.c returnleft.c returnright.c uvbar.c
  group Keyboard
    ../../../user/GUITASK/: cancelbutton.c PingFang_Regular60.c pyinput.c SmartPhoneKeyPad.c sogoupinyin.c yesbutton.c
target hello_world flexspi_nor_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: as above
  c include: ..\..\boards;..\..\..\user;..\..\..\user\bsp\lcd;..\..\..\user\bsp\led;..\..\middleware\emwin\emWin_Config;..\..\middleware\emwin\emWin_header;..\..\..\rtthread\include;..\..\..\rtthread\components\drivers\include;..\..\..\rtthread\components\libc\compilers\armlibc;..\..\devices\MIMXRT1052\drivers;..\..\CMSIS\Include;..\..\devices;..\..\devices\MIMXRT1052;..\..\devices\MIMXRT1052\utilities;..\..\devices\MIMXRT1052\xip;..\..\devices\MIMXRT1052\utilities\io;..\..\devices\MIMXRT1052\utilities\log;..\..\devices\MIMXRT1052\utilities\str
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target hello_world sdram_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: --remove
target hello_world sdram_txt_debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: cubic_further.out
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: ..\..\CMSIS\Include;..\..\devices;..\..\devices\MIMXRT1052\drivers;..\..\devices\MIMXRT1052;..\..\devices\MIMXRT1052\utilities\io;..\..\devices\MIMXRT1052\utilities\log;..\..\devices\MIMXRT1052\utilities\str;..\..\devices\MIMXRT1052\utilities;..\..\devices\MIMXRT1052\xip;..\..\boards;..\..\..\user\bsp\lcd;..\..\middleware\emwin\emWin_Config;..\..\middleware\emwin\emWin_header;..\..\..\rtthread\3.0.3\include;..\..\..\rtthread\3.0.3\components\drivers\include;..\..\..\rtthread\3.0.3\components\libc\compilers\armlibc;..\..\..\user;..\..\..\user\bsp\led;..\..\..\user\bsp\lcd;..\..\..\user\bsp\touchft6336;..\..\..\user\bsp;..\..\..\user\fatfs;..\..\..\xip
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram_txt.scf
  link misc: --remove
target hello_world release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_ram.scf
  link misc: --remove
target hello_world flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
target hello_world sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: --remove
target hello_world sdram_txt_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram_txt.scf
  link misc: --remove
